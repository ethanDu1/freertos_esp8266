# IAR project stm767.ewp, settings and files
configuration stm767 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx; ENABLE_LOG_ERROR; ENABLE_IOT_TRACE; ENABLE_LOG_DEBUG; ENABLE_AT_CMD; AUTH_MODE_DYNAMIC; SINGLE_TASK
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../Inc/at; ../Inc/certs; ../Inc/mqtt; ../Inc/platform; ../Inc/sdk-impl; ../Inc/utils; ../Inc/shadow; ../Inc/dev_model; ../Inc/ota
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: stm767.hex
  ILINK.IlinkOutputFile: stm767.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f767xx.s
  group Application/EWARM/at
    ../Inc/at/: at_client.h at_inf.h at_ringbuff.h at_utils.h
  group Application/EWARM/certs
    ../Inc/certs/: ca.h
  group Application/EWARM/dev_model
    ../Inc/dev_model/: dm_config.h dm_internal.h
  group Application/EWARM/mqtt
    ../Inc/mqtt/: mqtt_client.h mqtt_client_net.h
  group Application/EWARM/ota
    ../Inc/ota/: ota_config.h ota_internal.h
  group Application/EWARM/platform
    ../Inc/platform/: HAL_Timer_Platform.h
  group Application/EWARM/sdk-impl
    ../Inc/sdk-impl/: uiot_defs.h uiot_export.h uiot_export_dm.h uiot_export_mqtt.h uiot_export_ota.h uiot_export_shadow.h uiot_import.h uiot_internal.h
  group Application/EWARM/shadow
    ../Inc/shadow/: shadow_client.h shadow_client_common.h shadow_client_json.h
  group Application/EWARM/utils
    ../Inc/utils/: json_parser.h lite-list.h lite-utils.h utils_httpc.h utils_list.h utils_md5.h utils_net.h utils_timer.h
  group Application/User
    ../Src/: main.c main_dynamic.c main_mqtt.c main_ota.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/at
    ../Src/at/: at_client.c at_inf.c at_ringbuff.c at_utils.c
  group Application/User/certs
    ../Src/certs/: ca.c
  group Application/User/dev_model
    ../Src/dev_model/: dm_client.c dm_mqtt.c
  group Application/User/mqtt
    ../Src/mqtt/: mqtt_client.c mqtt_client_common.c mqtt_client_connect.c mqtt_client_net.c mqtt_client_publish.c mqtt_client_subscribe.c mqtt_client_unsubscribe.c mqtt_client_yield.c
  group Application/User/ota
    ../Src/ota/: ota_client.c ota_fetch.c ota_lib.c ota_mqtt.c
  group Application/User/platform
    ../Src/platform/: esp8266.c HAL_OS_freertos.c HAL_Timer_freertos.c sim800c.c
  group Application/User/shadow
    ../Src/shadow/: shadow_client.c shadow_client_common.c shadow_client_json.c shadow_client_manager.c
  group Application/User/utils
    ../Src/utils/: json_parser.c json_token.c string_utils.c utils_httpc.c utils_list.c utils_md5.c utils_net.c utils_timer.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
